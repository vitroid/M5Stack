# Repository vitroid/M5Stack (continued)

## KiCad design Atom/LaserBlinker/hardware/front-core/front-core.kicad_pcb (continued)

Board: 2 copper layers, 36.0 x 120.0 mm, 102 parts (0 on the bottom side), 66 nets.

File Atom/LaserBlinker/hardware/front-core/fab/jlcpcb-bom.csv:

"Comment","Designator","Footprint","JLCPCB Part #"
"MLT-8530","BZ1","Buzzer_Beeper:MagneticBuzzer_CUI_CMT-8504-100-SMT","C94599"
"22uF/25V","C1,C2","Capacitor_SMD:C_1206_3216Metric","C12891"
"100nF/50V","C3","Capacitor_SMD:C_0603_1608Metric","C14663"
"100nF/25V","C4","Capacitor_SMD:C_0603_1608Metric","C14663"
"22uF/10V","C5,C6,C17","Capacitor_SMD:C_0805_2012Metric","C45783"
"220uF/10V","C7","Capacitor_SMD:CP_Elec_6.3x7.7","C128268"
"1uF","C8,C14","Capacitor_SMD:C_0603_1608Metric","C15849"
"10uF","C9,C10,C12,C24","Capacitor_SMD:C_0603_1608Metric","C19702"
"100nF","C11,C13,C15,C16,C19-C23","Capacitor_SMD:C_0603_1608Metric","C14663"
"1uF/25V","C18","Capacitor_SMD:C_0603_1608Metric","C15849"
"SS34","D1,D11","Diode_SMD:D_SMA","C8678"
"B5819W","D2-D5,D10","Diode_SMD:D_SOD-123","C8598"
"SMAJ15A","D6","Diode_SMD:D_SMA","C123805"
"STATUS_BLUE","D7","LED_SMD:LED_0603_1608Metric","C72041"
"SM712","D8","Package_TO_SOT_SMD:SOT-23","C15919"
"PG_GREEN","D9","LED_SMD:LED_0603_1608Metric","C72043"
"3A_1812","F1","Fuse:Fuse_1812_4532Metric","C70069"
"1.1A_NAVI","F2","Fuse:Fuse_1206_3216Metric","C70059"
"1.5A_TRUNK","F3","Fuse:Fuse_1206_3216Metric","C70062"
"RJ45_CAT5_TRUNK","J1","Connector_RJ:RJ45_Amphenol_RJHSE5380","C386757"
"USB_PWR_12V_PD","J2","Connector_USB:USB_C_Receptacle_HRO_TYPE-C-31-M-12","C165948"
"USB_DBG_PC","J3","Connector_USB:USB_C_Receptacle_HRO_TYPE-C-31-M-12","C165948"
"GROVE_NAVI_HY2.0","J4","Connector_JST:JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal","C265452"
"4.7uH/4.5A","L1","Inductor_SMD:L_6.3x6.3_H3","C408412"
"TURN_LAMP_L_2P","P2","TerminalBlock_4Ucon:TerminalBlock_4Ucon_1x02_P3.50mm_Horizontal","C474892"
"TURN_LAMP_R_2P","P3","TerminalBlock_4Ucon:TerminalBlock_4Ucon_1x02_P3.50mm_Horizontal","C474892"
"HEADLIGHT_12V_2P","P4","TerminalBlock_4Ucon:TerminalBlock_4Ucon_1x02_P3.50mm_Horizontal","C474892"
"AO3400A","Q1-Q3","Package_TO_SOT_SMD:SOT-23","C20917"
"75k_1%","R1","Resistor_SMD:R_0603_1608Metric","C23240"
"10k_1%","R2","Resistor_SMD:R_0603_1608Metric","C25804"
"5.1k","R3,R4","Resistor_SMD:R_0603_1608Metric","C23186"
"10k","R5,R6,R9,R10,R16,R18,R21,R25,R27,R29,R31,R37,R40","Resistor_SMD:R_0603_1608Metric","C25804"
"1k","R8,R26,R28,R30,R32","Resistor_SMD:R_0603_1608Metric","C21190"
"120R","R11","Resistor_SMD:R_0805_2012Metric","C17440"
"330R","R14","Resistor_SMD:R_0603_1608Metric","C23138"
"100R","R15,R17,R36","Resistor_SMD:R_0603_1608Metric","C22775"
"1k_0805","R22","Resistor_SMD:R_0805_2012Metric","C17513"
"24k_1%","R23","Resistor_SMD:R_0603_1608Metric","C23350"
"4.7k","R24","Resistor_SMD:R_0603_1608Metric","C23162"
"100k_1%","R33","Resistor_SMD:R_0603_1608Metric","C25803"
"22k_1%","R34","Resistor_SMD:R_0603_1608Metric","C25768"
"15R_0805","R35","Resistor_SMD:R_0805_2012Metric","C17471"
"220R","R38,R39","Resistor_SMD:R_0603_1608Metric","C22962"
"SW_TURN_L_2P","S1","TerminalBlock:TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal","C557685"
"SW_BRAKE_L_2P","S2","TerminalBlock:TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal","C557685"
"SW_BRAKE_R_2P","S3","TerminalBlock:TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal","C557685"
"STATUS_WS2812_3P","S4","TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal","C557686"
"SW_TURN_R_2P","S5","TerminalBlock:TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal","C557685"
"RST","SW1","Button_Switch_SMD:SW_Push_1P1T_XKB_TS-1187A","C318884"
"BOOT","SW2","Button_Switch_SMD:SW_Push_1P1T_XKB_TS-1187A","C318884"
"CH224K","U0","Package_SO:SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm","C970725"
"TPS54302DDCR","U1","Package_TO_SOT_SMD:SOT-23-6","C311038"
"AP2112K-3.3","U2","Package_TO_SOT_SMD:SOT-23-5","C51118"
"SP3485EN-L/TR","U3","Package_SO:SOIC-8_3.9x4.9mm_P1.27mm","C9945"
"ESP32-S3-MINI-1-N8","U4","RF_Module:ESP32-S2-MINI-1","C2913206"
"SN74LV1T34DBVR","U6","Package_TO_SOT_SMD:SOT-23-5","C100022"
"USBLC6-2SC6","U7","Package_TO_SOT_SMD:SOT-23-6","C7519"

## KiCad design Atom/LaserBlinker/hardware/rear-core-claude/rear-core-claude.kicad_pcb

File Atom/LaserBlinker/hardware/rear-core-claude/README.md:

# rear-core-claude

`docs/rear-pcb-design.md` に基づく後方ユニット中核基板（ESP32-C3-MINI-1）の KiCad 10 プロジェクト。
回路図・基板・製造データはすべて `scripts/design.py`（部品とネットの一覧）から自動生成する。

## 現状

| 項目 | 結果 |
|---|---|
| 基板サイズ | 40 × 55 mm、2 層、片面 SMD |
| ERC | 0 件 |
| 回路図 ↔ design.py 照合 | 207 ピン / 40 ネット、不一致 0 |
| DRC | エラー 0、未配線 0、回路図との不一致 0（警告 4: ESP32 モジュール自身のシルクが基板端に掛かるもの） |
| 配線 | Freerouting 自動配線、表裏 GND ベタ + スティッチングビア |

設計書の目安 30×40 mm は、部品のコートヤード合計（約 1,200 mm²）とアンテナ禁止帯を考えると片面実装では入らない。
生成スクリプトは 30×40 から順に試し、配置と配線が両方完了した最小サイズを採用する（38×50 では未配線 2 本が残った）。

## 再生成

```sh
KP=/Applications/KiCad/KiCad.app/Contents/Frameworks/Python.framework/Versions/3.9/bin/python3
$KP scripts/gen_sch.py     # ライブラリ・プロジェクト・回路図
$KP scripts/check_sch.py   # ERC とネットリスト照合（out_netlist.xml は gen_pcb.py が使う）
$KP scripts/gen_pcb.py     # 配置 → Freerouting → GND ベタ（約 2 分）
$KP scripts/gen_fab.py     # fab/ に JLCPCB 用データ、out/ に画像、回路図 PDF
```

Freerouting 1.9.0 の jar を `~/.cache/freerouting/` に置いておくこと。

## 製造データ（fab/）

- `rear-core-claude-gerber.zip`: ガーバーとドリル
- `rear-core-claude-bom.csv` / `rear-core-claude-cpl.csv`: JLCPCB PCBA 用。J1〜J3（スルーホールのコネクタ）、JP1/JP2、TP1 は実装対象外
- LCSC 番号が未指定の部品: C1, C2（22µF/25V 1206）、C8（220µF/10V 電解）、F1（3A 1812 ポリスイッチ）。発注時に選ぶ

Parts:
C1, C2: 22uF/25V; C_1206_3216Metric
C3: 100nF/50V; C_0603_1608Metric; LCSC C14663
C4, C14, C15, C18, C19: 100nF; C_0603_1608Metric; LCSC C14663
C5, C6, C7: 22uF/10V; C_0805_2012Metric; LCSC C45783
C8: 220uF/10V; CP_Elec_6.3x7.7
C9, C11, C16: 1uF; C_0603_1608Metric; LCSC C15849
C10, C12, C13, C17: 10uF; C_0603_1608Metric; LCSC C19702
D1: SS34; D_SMA; LCSC C8678
D2, D3, D4, D5: B5819W; D_SOD-123; LCSC C8598
F1: 3A; Fuse_1812_4532Metric
J1: TRUNK 12V/RS485; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J2: WS2812; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J3: LASER L/R; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
JP1: TERM; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
JP2: V_LASER 5V/12V; SolderJumper-3_P1.3mm_Bridged12_Pad1.0x1.5mm
L1: 4.7uH 4A; L_Bourns_SRN6045TA; LCSC C408412
LED1: BLUE; LED_0603_1608Metric; LCSC C72041
Q1, Q2: AO3400A; SOT-23; LCSC C20917
R1: 75k 1%; R_0603_1608Metric; LCSC C23242
R2: 10k 1%; R_0603_1608Metric; LCSC C25804
R3, R4: 5.1k; R_0603_1608Metric; LCSC C23186
R5, R6, R8, R9, R10, R16, R18: 10k; R_0603_1608Metric; LCSC C25804
R7: 120; R_0603_1608Metric; LCSC C22787
R11: 1k; R_0603_1608Metric; LCSC C21190
R12, R13: 4.7k; R_0603_1608Metric; LCSC C23162
R14: 330; R_0603_1608Metric; LCSC C23138
R15, R17: 100; R_0603_1608Metric; LCSC C22775
SW1: RST; SW_Push_1P1T_XKB_TS-1187A; LCSC C318884
SW2: BOOT; SW_Push_1P1T_XKB_TS-1187A; LCSC C318884
TP1: IO0; TestPoint_Pad_D1.0mm
TVS1: SMBJ15A; D_SMB; LCSC C73385
TVS2: SM712; SOT-23; LCSC C15919
U1: TPS54302DDCR; SOT-23-6; LCSC C311038
U2: AP2112K-3.3; SOT-23-5; LCSC C51118
U3: SP3485EN; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C9945
U4: ESP32-C3-MINI-1-N4; ESP32-C3-MINI-1; LCSC C2838502
U5: LIS3DHTR; LGA-16_3x3mm_P0.5mm_LayoutBorder3x5y; LCSC C15134
U6: SN74LV1T34DBVR; SOT-23-5; LCSC C100022
USB1: TYPE-C-31-M-12; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948

Connections:
/12V_F: D1.2 (A), F1.2
/+3V3: C11.1, C12.1, C13.1, C14.1, C15.1, C17.1, C18.1, R5.2, R8.2, R9.2, R10.2, R11.1, R12.2, R13.2, U2.5 (VOUT), U3.8 (VCC), U4.3 (3V3), U5.1 (VDD_IO), U5.8 (CS), U5.14 (VDD)
/+5V: C5.1, C6.1, C7.1, C8.1, C19.1, D2.2 (A), J2.1, JP2.1 (A), L1.2, R1.1, U6.5 (VCC)
/+12V: C1.1, C2.1, C3.1, D1.1 (K), JP2.3 (B), TVS1.1 (K), U1.3 (VIN)
/+12V_IN: F1.1, J1.1
/BOOT_BTN: R9.1, SW2.1, U4.23 (IO9)
/BST: C4.1, U1.6 (BOOT)
/CC1: R3.1, USB1.A5 (CC1)
/CC2: R4.1, USB1.B5 (CC2)
/EN: C16.1, R8.1, SW1.1, U4.8 (EN)
/FB: R1.2, R2.1, U1.4 (FB)
/G2_STRAP: R10.1, U4.5 (IO2)
/GATE_L: Q1.1 (G), R15.2, R16.1
/GATE_R: Q2.1 (G), R17.2, R18.1
/GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, J1.2, J2.3, Q1.2 (S), Q2.2 (S), R2.2, R3.2, R4.2, R6.2, R16.2, R18.2, SW1.2, SW2.2, TVS1.2 (A), TVS2.3 (common), U1.1 (GND), U2.2 (GND), U3.5 (GND), U4.1 (GND), U4.2 (GND), U4.11 (GND), U4.14 (GND), U4.36 (GND), U4.37 (GND), U4.38 (GND), U4.39 (GND), U4.40 (GND), U4.41 (GND), U4.42 (GND), U4.43 (GND), U4.44 (GND), U4.45 (GND), U4.46 (GND), U4.47 (GND), U4.48 (GND), U4.49 (GND), U4.50 (GND), U4.51 (GND), U4.52 (GND), U4.53 (GND), U5.5 (GND), U5.7 (SDO), U5.10 (GND), U5.12 (GND), U6.3 (GND), USB1.A1 (GND), USB1.A12 (GND), USB1.B1 (GND), USB1.B12 (GND), USB1.SH (SHIELD)
/I2C_SCL: R13.1, U4.21 (IO7), U5.4 (SPC)
/I2C_SDA: R12.1, U4.20 (IO6), U5.6 (SDI)
/IMU_INT1: U4.13 (IO1), U5.11 (INT1)
/IO0_TP: TP1.1, U4.12 (IO0)
/LASER_L: R15.1, U4.18 (IO4)
/LASER_L-: D4.2 (A), J3.2, Q1.3 (D)
/LASER_R: R17.1, U4.19 (IO5)
/LASER_R-: D5.2 (A), J3.4, Q2.3 (D)
/LED_A: LED1.2 (A), R11.2
/LED_DATA_5V: J2.2, R14.2
/LINK_RX: R5.1, U3.1 (RO), U4.30 (RXD0/IO20)
/LINK_TX: U3.4 (DI), U4.31 (TXD0/IO21)
/RS485_A: J1.3, R7.1, TVS2.1 (A1), U3.6 (A)
/RS485_B: J1.4, JP1.2 (B), TVS2.2 (A2), U3.7 (B)
/RS485_DE: R6.1, U3.2 (~RE), U3.3 (DE), U4.6 (IO3)
/STATUS_LED: LED1.1 (K), U4.22 (IO8)
/SW: C4.2, L1.1, U1.2 (SW)
/TERM: JP1.1 (A), R7.2
/USB_DN: U4.26 (IO18/USB_D-), USB1.A7 (D-), USB1.B7 (D-)
/USB_DP: U4.27 (IO19/USB_D+), USB1.A6 (D+), USB1.B6 (D+)
/V5_LOGIC: C9.1, C10.1, D2.1 (K), D3.1 (K), U2.1 (VIN), U2.3 (EN)
/VBUS: D3.2 (A), USB1.A4 (VBUS), USB1.A9 (VBUS), USB1.B4 (VBUS), USB1.B9 (VBUS)
/V_LASER: D4.1 (K), D5.1 (K), J3.1, J3.3, JP2.2 (C)
/WS_DIN: U4.16 (IO10), U6.2 (A)
/WS_OUT: R14.1, U6.4 (Y)

Notes on the sheet:
■ 端子
■ 電源 入力保護
■ 電源 12V→5V
■ 電源 3.3V
■ USB
■ RS-485
■ MCU
■ IMU
■ WS2812
■ レーザー
■ PWR_FLAG

Board: 2 copper layers, 40.0 x 55.0 mm, 64 parts (0 on the bottom side), 40 nets.

File Atom/LaserBlinker/hardware/rear-core-claude/fab/rear-core-claude-bom.csv:

Comment,Designator,Footprint,LCSC Part #
22uF/25V,"C1,C2",C_1206_3216Metric,
10uF,"C10,C12,C13,C17",C_0603_1608Metric,C19702
100nF/50V,C3,C_0603_1608Metric,C14663
100nF,"C4,C15,C14,C18,C19",C_0603_1608Metric,C14663
22uF/10V,"C5,C6,C7",C_0805_2012Metric,C45783
220uF/10V,C8,CP_Elec_6.3x7.7,
1uF,"C9,C11,C16",C_0603_1608Metric,C15849
SS34,D1,D_SMA,C8678
B5819W,"D2,D3,D4,D5",D_SOD-123,C8598
3A,F1,Fuse_1812_4532Metric,
4.7uH 4A,L1,L_Bourns_SRN6045TA,C408412
BLUE,LED1,LED_0603_1608Metric,C72041
AO3400A,"Q1,Q2",SOT-23,C20917
75k 1%,R1,R_0603_1608Metric,C23242
1k,R11,R_0603_1608Metric,C21190
4.7k,"R12,R13",R_0603_1608Metric,C23162
330,R14,R_0603_1608Metric,C23138
100,"R15,R17",R_0603_1608Metric,C22775
10k 1%,R2,R_0603_1608Metric,C25804
5.1k,"R3,R4",R_0603_1608Metric,C23186
10k,"R5,R6,R8,R9,R10,R16,R18",R_0603_1608Metric,C25804
120,R7,R_0603_1608Metric,C22787
RST,SW1,SW_Push_1P1T_XKB_TS-1187A,C318884
BOOT,SW2,SW_Push_1P1T_XKB_TS-1187A,C318884
SMBJ15A,TVS1,D_SMB,C73385
SM712,TVS2,SOT-23,C15919
TPS54302DDCR,U1,SOT-23-6,C311038
AP2112K-3.3,U2,SOT-23-5,C51118
SP3485EN,U3,SOIC-8_3.9x4.9mm_P1.27mm,C9945
ESP32-C3-MINI-1-N4,U4,ESP32-C3-MINI-1,C2838502
LIS3DHTR,U5,LGA-16_3x3mm_P0.5mm_LayoutBorder3x5y,C15134
SN74LV1T34DBVR,U6,SOT-23-5,C100022
TYPE-C-31-M-12,USB1,USB_C_Receptacle_HRO_TYPE-C-31-M-12,C165948

## Code that names these connections

File Atom/LaserBlinker/hardware/rear-core-claude/scripts/design.py (part):

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    # ---------------- 外部端子 ----------------
    dict(ref="J1", lib="Connector_Generic:Conn_01x04", value="TRUNK 12V/RS485",
         fp="Connector_JST:JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical", lcsc="",
         pins={"1": "+12V_IN", "2": "GND", "3": "RS485_A", "4": "RS485_B"}, group="端子"),
    dict(ref="J2", lib="Connector_Generic:Conn_01x03", value="WS2812",
         fp="Connector_JST:JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical", lcsc="",
         pins={"1": "+5V", "2": "LED_DATA_5V", "3": "GND"}, group="端子"),
    dict(ref="J3", lib="Connector_Generic:Conn_01x04", value="LASER L/R",
         fp="Connector_JST:JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical", lcsc="",
         pins={"1": "V_LASER", "2": "LASER_L-", "3": "V_LASER", "4": "LASER_R-"}, group="端子"),

    # ---------------- ① 電源: 入力保護 ----------------
    dict(ref="F1", lib="Device:Polyfuse", value="3A", fp="Fuse:Fuse_1812_4532Metric",
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    # ---------------- ① 電源: 12V→5V Buck ----------------
    dict(ref="U1", lib="Regulator_Switching:TPS54302", value="TPS54302DDCR",
         fp="Package_TO_SOT_SMD:SOT-23-6", lcsc="C311038",
         pins={"1": "GND", "2": "SW", "3": "+12V", "4": "FB", "6": "BST"},
         group="電源 12V→5V", near=(9.0, 30.0)),
    C("C4", "100nF", "BST", "SW", lcsc="C14663", group="電源 12V→5V", near=("U1", "6")),
    dict(ref="L1", lib="Device:L", value="4.7uH 4A", fp="Inductor_SMD:L_Bourns_SRN6045TA",
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    schottky("D3", "V5_LOGIC", "VBUS", group="電源 3.3V", near=("U2", "1")),
    dict(ref="U2", lib="Regulator_Linear:AP2112K-3.3", value="AP2112K-3.3",
         fp="Package_TO_SOT_SMD:SOT-23-5", lcsc="C51118",
         pins={"1": "V5_LOGIC", "2": "GND", "3": "V5_LOGIC", "5": "+3V3"},
         group="電源 3.3V", near=(4.0, 9.0)),
    C("C9", "1uF", "V5_LOGIC", "GND", lcsc="C15849", group="電源 3.3V", near=("U2", "1")),
    C("C10", "10uF", "V5_LOGIC", "GND", lcsc="C19702", group="電源 3.3V", near=("U2", "1")),
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    # ---------------- ③ RS-485 ----------------
    dict(ref="U3", lib="Interface_UART:SP3485EN", value="SP3485EN",
         fp="Package_SO:SOIC-8_3.9x4.9mm_P1.27mm", lcsc="C9945",
         pins={"1": "LINK_RX", "2": "RS485_DE", "3": "RS485_DE", "4": "LINK_TX",
               "5": "GND", "6": "RS485_A", "7": "RS485_B", "8": "+3V3"},
         group="RS-485", near=(15.0, 27.0)),
    C("C15", "100nF", "+3V3", "GND", lcsc="C14663", group="RS-485", near=("U3", "8")),
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    R("R7", "120", "RS485_A", "TERM", lcsc="C22787", group="RS-485", near=("U3", "6")),
    dict(ref="JP1", lib="Jumper:SolderJumper_2_Bridged", value="TERM",
         fp="Jumper:SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm", lcsc="",
         pins={"1": "TERM", "2": "RS485_B"}, group="RS-485", near=("U3", "7")),
    dict(ref="TVS2", lib="Diode:SM712_SOT23", value="SM712", fp="Package_TO_SOT_SMD:SOT-23",
         lcsc="C15919", pins={"1": "RS485_A", "2": "RS485_B", "3": "GND"},
         group="RS-485", near=("J1", "3")),

    # ---------------- ④ MCU ----------------
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         lcsc="C318884", pins={"1": "EN", "2": "GND"}, group="MCU", near=("U4", "8")),
    R("R9", "10k", "BOOT_BTN", "+3V3", lcsc="C25804", group="MCU", near=("U4", "23")),
    dict(ref="SW2", lib="Switch:SW_Push", value="BOOT", fp="Button_Switch_SMD:SW_Push_1P1T_XKB_TS-1187A",
         lcsc="C318884", pins={"1": "BOOT_BTN", "2": "GND"}, group="MCU", near=("U4", "23")),
    R("R10", "10k", "G2_STRAP", "+3V3", lcsc="C25804", group="MCU", near=("U4", "5")),
    R("R11", "1k", "+3V3", "LED_A", lcsc="C21190", group="MCU", near=("U4", "22")),
    dict(ref="LED1", lib="Device:LED", value="BLUE", fp="LED_SMD:LED_0603_1608Metric",
         lcsc="C72041", pins={"1": "STATUS_LED", "2": "LED_A"}, group="MCU", near=("U4", "22")),
    dict(ref="TP1", lib="Connector:TestPoint", value="IO0", fp="TestPoint:TestPoint_Pad_D1.0mm",
         lcsc="", pins={"1": "IO0_TP"}, group="MCU", near=("U4", "12")),

    # ---------------- ⑥ 加速度センサ ----------------
    dict(ref="U5", lib="Sensor_Motion:LIS3DH", value="LIS3DHTR",
         fp="Package_LGA:LGA-16_3x3mm_P0.5mm_LayoutBorder3x5y", lcsc="C15134",
         pins={"1": "+3V3", "14": "+3V3", "8": "+3V3", "7": "GND", "6": "I2C_SDA",
               "4": "I2C_SCL", "11": "IMU_INT1", "5": "GND", "10": "GND", "12": "GND"},
         group="IMU", near=(18.0, 20.0)),
    C("C17", "10uF", "+3V3", "GND", lcsc="C19702", group="IMU", near=("U5", "14")),
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    # ---------------- ⑤ 出力: WS2812 レベルシフト ----------------
    dict(ref="U6", lib="Logic_LevelTranslator:SN74LV1T34DBV", value="SN74LV1T34DBVR",
         fp="Package_TO_SOT_SMD:SOT-23-5", lcsc="C100022",
         pins={"2": "WS_DIN", "3": "GND", "4": "WS_OUT", "5": "+5V"},
         group="WS2812", near=("J2", "2")),
    C("C19", "100nF", "+5V", "GND", lcsc="C14663", group="WS2812", near=("U6", "5")),
    R("R14", "330", "WS_OUT", "LED_DATA_5V", lcsc="C23138", group="WS2812", near=("J2", "2")),
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    # ---------------- ⑤ 出力: レーザー L/R ----------------
    dict(ref="JP2", lib="Jumper:SolderJumper_3_Bridged12", value="V_LASER 5V/12V",
         fp="Jumper:SolderJumper-3_P1.3mm_Bridged12_Pad1.0x1.5mm", lcsc="",
         pins={"1": "+5V", "2": "V_LASER", "3": "+12V"}, group="レーザー", near=("J3", "1")),
    dict(ref="Q1", lib="Transistor_FET:AO3400A", value="AO3400A", fp="Package_TO_SOT_SMD:SOT-23",
         lcsc="C20917", pins={"1": "GATE_L", "2": "GND", "3": "LASER_L-"},
         group="レーザー", near=("J3", "2")),
    dict(ref="Q2", lib="Transistor_FET:AO3400A", value="AO3400A", fp="Package_TO_SOT_SMD:SOT-23",
         lcsc="C20917", pins={"1": "GATE_R", "2": "GND", "3": "LASER_R-"},
         group="レーザー", near=("J3", "4")),
    R("R15", "100", "LASER_L", "GATE_L", lcsc="C22775", group="レーザー", near=("Q1", "1")),
    R("R16", "10k", "GATE_L", "GND", lcsc="C25804", group="レーザー", near=("Q1", "1")),
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
File Atom/LaserBlinker/hardware/rear-core/scripts/generate_kicad.py (part):

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    # Pin 6 (Green) -> NC guard between GND and +12V
    sb.nc(j1["6"])

    # Pin 4 & 5 (Blue pair) -> V12_RAW (paralleled +12V input)
    sb.chain(j1["5"], (48.26, j1["5"][1]), (48.26, j1["4"][1]), j1["4"])
    sb.junc(48.26, j1["5"][1])
    sb.stub((48.26, j1["5"][1]), "V12_RAW", dx=7.62)
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    # Pin 3 (White/Green) -> NC guard between +12V and RS-485
    sb.nc(j1["3"])

    # Pin 1 & 2 (Orange twisted pair) -> RS485_A / RS485_B
    sb.stub(j1["2"], "RS485_B", dx=15.24)
    sb.stub(j1["1"], "RS485_A", dx=15.24)

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    )
    # Name the fused node so PCB netclass keeps F1→D1 as fat copper (not Default 0.2mm)
    sb.wire(*f1["2"], *d1["2"])
    sb.label("V12_FUSED", (f1["2"][0] + d1["2"][0]) / 2.0, f1["2"][1], angle=0)

    # Keep +12V rail, PWR_FLAG & D6 TVS before C1..C3
    # D1 cathode (pin 1 with angle=180 placement → schematic pin "1" is +12V side)
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    )
    sb.wire(*u1["2"], *l1["1"])
    # Switch node carries buck peak current — must not stay as anonymous Default 0.2mm
    sb.label("BUCK_SW", (u1["2"][0] + l1["1"][0]) / 2.0, u1["2"][1], angle=0)
    sb.wire(*l1["2"], 317.50, 43.18)

    r1 = sb.place(
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    sb.chain(d3["1"], (330.20, 55.88), (330.20, 43.18))
    sb.junc(330.20, 43.18)
    # OR-diode cathodes → LDO VIN (same class of oversight as V12_FUSED)
    sb.label("V5_OR", 330.20, 43.18, angle=0)
    sb.wire(330.20, 43.18, 330.20, 35.56)
    sb.place_pwr("PWR_FLAG", 330.20, 35.56)
    sb.chain((341.63, 43.18), (341.63, 45.72), u2["3"])
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    sb.place_pwr("+3V3", 157.48, u4["5"][1] - 3.81)

    sb.stub(u4["6"], "RS485_DE", dx=-13.97)
    sb.stub(u4["18"], "EXP_CMD", dx=-13.97)  # GPIO4 → J3-4 (3.3V UART TX / command)
    sb.nc(u4["19"])  # GPIO5 reserved / unused after laser drivers removed
    sb.stub(u4["20"], "I2C_SDA", dx=-13.97)
    sb.stub(u4["21"], "I2C_SCL", dx=-13.97)
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    sb.rail_at(c14["1"], "+3V3", dy=-2.54)
    sb.gnd_at(c14["2"], dy=2.54)

    # RO (Pin 1) -> LINK_RX + R9 (10k pull-up to +3V3)
    sb.wire(*u3["1"], 261.62, u3["1"][1])
    sb.label("LINK_RX", 261.62, u3["1"][1], angle=180)
    r9 = sb.place(
        "Device:R", "R9", "10k", 273.05, 134.62, angle=0,
        footprint=FP_R0603, lcsc="C25804", ref_offset=(-5.08, -1.27), val_offset=(-5.08, 1.27),
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    sb.wire(*r9["2"], 273.05, u3["1"][1])
    sb.junc(273.05, u3["1"][1])

    # ~RE (Pin 2) & DE (Pin 3) tied together -> RS485_DE + R10 (10k pull-down at x=260.35)
    sb.chain(u3["2"], (275.59, u3["2"][1]), (275.59, u3["3"][1]), u3["3"])
    sb.junc(275.59, u3["3"][1])
    sb.wire(275.59, u3["3"][1], 260.35, u3["3"][1])
    sb.junc(260.35, u3["3"][1])
    sb.label("RS485_DE", 266.70, u3["3"][1], angle=0)
    r10 = sb.place(
        "Device:R", "R10", "10k", 260.35, 165.10, angle=0,
        footprint=FP_R0603, lcsc="C25804", ref_offset=(-4.45, -1.27), val_offset=(-4.45, 1.27),
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    sb.wire(260.35, u3["3"][1], *r10["1"])
    sb.gnd_at(r10["2"], dy=3.81)

    # DI (Pin 4) -> LINK_TX (stops at x=267.97, no crossing with x=260.35!)
    sb.stub(u3["4"], "LINK_TX", dx=-11.43)

    # RS485 A (Pin 6: y=144.78) & B (Pin 7: y=149.86) + Termination JP1/R11 + SM712 TVS (D8)
    sb.wire(*u3["6"], 337.82, u3["6"][1])
    sb.label("RS485_A", 337.82, u3["6"][1], angle=0)
    sb.wire(*u3["7"], 337.82, u3["7"][1])
    sb.label("RS485_B", 337.82, u3["7"][1], angle=0)

    # Termination: A (y=144.78) -> JP1 (vertical at x=312.42, y=156.21) -> R11 (120R at y=168.91) -> B
    # Wait: let's place JP1 & R11 below B (y=149.86) or between A & B? Between 144.78 and 149.86 is 5.08mm;
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    sb.wire(*r20["1"], 351.79, u5["7"][1])
    sb.place_pwr("GND", 351.79, u5["7"][1], angle=270)

    # SDI (Pin 6: y=154.94) -> I2C_SDA + R12 (4.7k pull-up)
    sb.wire(*u5["6"], 347.98, u5["6"][1])
    sb.label("I2C_SDA", 347.98, u5["6"][1], angle=180)
    # SPC (Pin 4: y=157.48) -> I2C_SCL + R13 (4.7k pull-up)
    sb.wire(*u5["4"], 347.98, u5["4"][1])
    sb.label("I2C_SCL", 347.98, u5["4"][1], angle=180)

    # CS (Pin 8: y=160.02) -> +3V3 (I2C mode enable)
    sb.chain(u5["8"], (360.68, u5["8"][1]), (360.68, 165.10))
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
File Atom/LaserBlinker/hardware/front-core/scripts/generate_front_kicad.py (part):

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
    # VBUS_PD bus at y=35.56 from J_PWR VBUS (53.34, 63.50) -> F1 -> D1 -> +12V
    sb.chain(jpwr["A4"], (68.58, jpwr["A4"][1]), (68.58, 35.56), (177.80, 35.56))
    sb.label("VBUS_PD", 152.40, 35.56, angle=0)

    # R_VBUS (R21: 10k) to U0.8 (VBUS sense at x=119.38)
    r21 = sb.place(
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        ref_offset=(0, -5.08), val_offset=(0, 5.08),
    )
    sb.wire(*f1["2"], *d1["2"])
    sb.label("V12_FUSED", (f1["2"][0] + d1["2"][0]) / 2.0, f1["2"][1], angle=0)
    sb.wire(*d1["1"], 226.06, 35.56)
    sb.junc(213.36, 35.56)
    sb.rail_at((213.36, 35.56), "+12V", dy=-5.08)
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        ref_offset=(0, -3.81), val_offset=(0, 3.81),
    )
    sb.wire(*u1["2"], *l1["1"])
    sb.label("BUCK_SW", (u1["2"][0] + l1["1"][0]) / 2.0, u1["2"][1], angle=0)
    sb.wire(*l1["2"], 439.42, 48.26)

    r1 = sb.place(
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    sb.wire(*d2["1"], *u2["1"])
    sb.chain(d3["1"], (452.12, 63.50), (452.12, 48.26))
    sb.junc(452.12, 48.26)
    sb.label("V5_LOGIC", 454.66, 48.26, angle=0)
    sb.wire(452.12, 48.26, 452.12, 40.64)
    sb.place_pwr("PWR_FLAG", 452.12, 40.64)

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    sb.wire(*r33["2"], *r34["1"])
    sb.junc(198.12, 342.90)
    sb.wire(198.12, 342.90, 223.52, 342.90)
    sb.label("VIN_12V_ADC", 223.52, 342.90, angle=0)
    sb.junc(215.90, 342.90)
    sb.wire(215.90, 342.90, *c23["1"])
    sb.gnd_at(r34["2"], dy=3.81)
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    sb.chain(c24["1"], (281.94, 317.50), (302.26, 317.50), r35["1"])
    sb.junc(281.94, 317.50)
    sb.wire(271.78, 317.50, 281.94, 317.50)
    sb.label("V5_LOGIC", 271.78, 317.50, angle=180)
    sb.gnd_at(c24["2"], dy=2.54)

    bz1 = sb.place(
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    sb.gnd_at(c15["2"], dy=2.54)

    sb.wire(*u3["1"], 386.08, u3["1"][1])
    sb.label("LINK_RX", 386.08, u3["1"][1], angle=180)
    r9 = sb.place(
        "Device:R", "R9", "10k", 397.51, 170.18, angle=0,
        footprint=FP_R0603, lcsc="C25804", ref_offset=(-5.08, -1.905), val_offset=(-5.08, 1.905),
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    sb.junc(400.05, u3["3"][1])
    sb.wire(400.05, u3["3"][1], 384.81, u3["3"][1])
    sb.junc(384.81, u3["3"][1])
    sb.label("RS485_DE", 391.16, u3["3"][1], angle=0)
    r10 = sb.place(
        "Device:R", "R10", "10k", 384.81, 200.66, angle=0,
        footprint=FP_R0603, lcsc="C25804", ref_offset=(-4.45, -1.905), val_offset=(-4.45, 1.905),
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    sb.stub(u3["4"], "LINK_TX", dx=-11.43)

    sb.wire(*u3["6"], 462.28, u3["6"][1])
    sb.label("RS485_A", 462.28, u3["6"][1], angle=0)
    sb.wire(*u3["7"], 462.28, u3["7"][1])
    sb.label("RS485_B", 462.28, u3["7"][1], angle=0)

    jp1 = sb.place(
        "Jumper:SolderJumper_2_Bridged", "JP1", "TERM_EN", 440.69, 198.12, angle=0,
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        footprint=FP_R0603, lcsc="C22962", ref_offset=(0, -3.175), val_offset=(0, 3.175),
    )
    sb.wire(*r38["1"], 472.44, 229.87)
    sb.label("NAVI_RX", 472.44, 229.87, angle=180)
    r40 = sb.place(
        "Device:R", "R40", "10k", 480.06, 220.98, angle=0,
        footprint=FP_R0603, lcsc="C25804", ref_offset=(-4.45, -1.27), val_offset=(-4.45, 1.27),
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
File Atom/LaserBlinker/src/front/pins.h:

#pragma once

// ESP32-C3 SuperMini — 前部マスタ
// スイッチは押下時に GND へ落ちる（INPUT_PULLUP）。
// G2/G8/G9 は起動ストラップ関連のため使用しない。

#define PIN_SW_TURN_L  0
#define PIN_SW_TURN_R  1
#define PIN_SW_BRAKE   3

// 12V 前ウインカー用 N-MOSFET（HIGH で点灯）
#define PIN_MOSFET_TURN_L 4
#define PIN_MOSFET_TURN_R 5

// 前部状態表示用 WS2812（左、右の2灯）
#define PIN_STATUS_WS2812 10
#define NUM_STATUS_LEDS   2
#define STATUS_BRIGHTNESS 64

// MAX485。現状は前→後の一方向で、DIへ送信する。
// ROを接続する場合は5VをC3へ入れないようレベル変換すること。
#define PIN_LINK_RX 20
#define PIN_LINK_TX 21

#define BLINK_HALF_MS      250
#define SW_DEBOUNCE_MS     30
#define LINK_SEND_MS       100  // 状態送信周期
